# Keil uVision project f103c8t6_test.uvprojx, settings and files
target f103c8t6_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: f103c8t6_test +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../HARDWARE;../HARDWARE/OLED;../HARDWARE/MyConfig;../HARDWARE/MOTOR;../HARDWARE/ENCODER;../HARDWARE/PID;../HARDWARE/CONTROL;../HARDWARE/PROTOCOL;../HARDWARE/MPU6050;../HARDWARE/MPU6050/eMPL;../HARDWARE/JY61P;../HARDWARE/KEY;../HARDWARE/MENU;../HARDWARE/LINE;../HARDWARE/BT_REMOTE;../HARDWARE/LINE_TASK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group HARDWARE
    ../HARDWARE/MyConfig/: myconfig.h
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/PROTOCOL/: protocol.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/JY61P/: jy61p.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MENU/: menu.c
    ../HARDWARE/LINE/: line.c
    ../HARDWARE/BT_REMOTE/: bt_remote.c
    ../HARDWARE/LINE_TASK/: line_task.c
software components: CMSIS:CORE 4.3.0
